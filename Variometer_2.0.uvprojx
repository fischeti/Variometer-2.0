# Keil uVision project Variometer_2.0.uvprojx, settings and files
target Variometer_2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Variometer_2.0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\AmbiqMicro\AmbiqSuite\boards\apollo2_evb\bsp;C:\AmbiqMicro\AmbiqSuite;C:\AmbiqMicro\AmbiqSuite\utils;C:\AmbiqMicro\AmbiqSuite\devices;C:\AmbiqMicro\AmbiqSuite\mcu\apollo2;C:\AmbiqMicro\AmbiqSuite\mcu\apollo2\regs
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\variometer_2.0.sct
  group src
    ./: variometer_2.0.c
  group utils
    C:/AmbiqMicro/AmbiqSuite/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ./: startup_keil.s
  group lib
    C:/AmbiqMicro/AmbiqSuite/boards/apollo2_evb/bsp/keil/bin/: libam_bsp.lib
    C:/AmbiqMicro/AmbiqSuite/mcu/apollo2/hal/keil/bin/: libam_hal.lib
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/5.3.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
